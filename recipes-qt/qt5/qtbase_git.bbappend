PACKAGECONFIG_GL_pn-qtbase_arm = "gles2 eglfs"