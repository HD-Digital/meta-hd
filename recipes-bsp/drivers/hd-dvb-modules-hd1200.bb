KV = "4.0.1"
SRCDATE = "20151009"

require hd-dvb-modules.inc

SRC_URI[md5sum] = "703c45bf0f147cbceb8e69a19c12396f"
SRC_URI[sha256sum] = "d730f07a238646fa60e9919b9d39139034432de92f2141bf0925087431d1c1f8"

COMPATIBLE_MACHINE = "hd1200"