KV = "4.7.3"
SRCDATE = "20160921"

require hd-dvb-modules.inc

SRC_URI[md5sum] = "c96afb82d46f34b7300b1eee97857785"
SRC_URI[sha256sum] = "8bf5d9b2ca2c6494131e52c4fe2511b47d9c4610c7f6a5c15aa9667b874032ad"

COMPATIBLE_MACHINE = "hd51"